# Keil uVision project STM32F411CEU6.uvprojx, settings and files
target STM32F411CEU6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411CEU6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares_User/SEGGER_RTT;../Middlewares_User/EasyLogger/inc;../Middlewares_User/EasyLogger/debug;../Drivers/CMSIS/Include;..\Z01_SYS;..\Z02_BSP\IIC;..\Z02_BSP\AHT21\sw_bsp_aht21_driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Middlewares_User\SEGGER_RTT
    ../Middlewares_User/SEGGER_RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares_User\EasyLogger
    ../Middlewares_User/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares_User/EasyLogger/port/: elog_port.c
    ../Middlewares_User/EasyLogger/debug/: debug.c
  group Z01_SYS
    ../Z01_SYS/: delay.c
  group Z02_BSP
    ../Z02_BSP/IIC/: iic.c
    ../Z02_BSP/AHT21/sw_bsp_aht21_driver/Src/: sw_bsp_aht21_driver.c
software components: CMSIS:CORE 4.3.0
