# Keil uVision project STM32F411CEU6.uvprojx, settings and files
target STM32F411CEU6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411CEU6 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares_User/SEGGER_RTT;../Middlewares_User/EasyLogger/inc;..\Middlewares_User\Ymodem;..\SysSupport\Debug;..\SysSupport\OS_init;..\BSP\AT24Cxx;..\BSP\W25Qxx;..\BSP\UART_Handler;..\Tasks\APP;..\Tasks\SWC_OTA;..\Middlewares_User\CRC\include;..\Middlewares_User\SFUD;..\Middlewares_User\SFUD\inc
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MDK-ARM
    ./: startup_stm32f411xe.s
  group Tasks
    ../Tasks/APP/: app.c
    ../Tasks/SWC_OTA/: swc_ota.c
  group SysSupport
    ../SysSupport/OS_init/: os_init.c
    ../SysSupport/Debug/: debug.c
  group BSP
    ../BSP/AT24Cxx/: iic.c at24cxx.c
    ../BSP/W25Qxx/: w25qxx.c w25qxx_Handler.c
    ../BSP/UART_Handler/: uart_handler.c
  group User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares_User/Ymodem
    ../Middlewares_User/Ymodem/: common.c ymodem.c
  group Middlewares_User/CRC
    ../Middlewares_User/CRC/src/: crcccitt.c
  group Middlewares_User/EasyLogger
    ../Middlewares_User/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares_User/EasyLogger/port/: elog_port.c
  group Middlewares_User/SEGGER_RTT
    ../Middlewares_User/SEGGER_RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares_User\SFUD
    ../Middlewares_User/SFUD/port/: sfud_port.c
    ../Middlewares_User/SFUD/src/: sfud_sfdp.c sfud.c
    ../Middlewares_User/SFUD/: sfud_adapter.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
