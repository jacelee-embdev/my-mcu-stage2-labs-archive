# Keil uVision project STM32F411CEU6_SPL.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411CEU6_SPL
  AfterMake: .\keil-build-viewer.exe
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\Core\Inc;..\Drivers\CMSIS;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Middlewares_User\SEGGER_RTT;..\Middlewares_User\EasyLogger\inc;..\Middlewares_User\Ymodem;..\Middlewares_User\Algorithms\AES;..\Tasks\Debug;..\Tasks\Bootloader;..\SYSTEM\delay;..\BSP\W25QXX;..\BSP\AT24Cxx;..\Middlewares_User\CRC\include;..\Middlewares_User\SFUD;..\Middlewares_User\SFUD\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\bootloader_noinit.sct
  group BSP
    ../BSP/W25QXX/: w25qxx.c w25qxx_Handler.c
    ../BSP/AT24Cxx/: at24cxx.c iic.c
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c flash.c gpio.c usart.c spi.c iwdg.c
    ../Core/: startup_stm32f411xe.s
  group Middlewares_User\SEGGER_RTT
    ../Middlewares_User/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h
  group Middlewares_User\easylogger
    ../Middlewares_User/EasyLogger/port/: elog_port.c
    ../Middlewares_User/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Middlewares_User\Ymodem
    ../Middlewares_User/Ymodem/: ymodem.c common.c
  group Middlewares_User\Algorithms\AES
    ../Middlewares_User/Algorithms/AES/: aes.c aes.h
  group Middlewares_User\CRC
    ../Middlewares_User/CRC/src/: crcccitt.c
  group Middlewares_User\SFUD
    ../Middlewares_User/SFUD/src/: sfud.c sfud_sfdp.c
    ../Middlewares_User/SFUD/port/: sfud_port.c
    ../Middlewares_User/SFUD/: sfud_adapter.c
  group SYSTEM\delay
    ../SYSTEM/delay/: delay.c delay.h
  group Drivers
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_spi.c stm32f4xx_iwdg.c
  group Tasks
    ../Tasks/Debug/: debug.c
    ../Tasks/Bootloader/: bootloader.c
