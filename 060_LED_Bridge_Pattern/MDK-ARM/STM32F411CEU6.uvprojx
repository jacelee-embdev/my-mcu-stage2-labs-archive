# Keil uVision project STM32F411CEU6.uvprojx, settings and files
target STM32F411CEU6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411CEU6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares_User/SEGGER_RTT;../Middlewares_User/EasyLogger/inc;../Middlewares_User/EasyLogger/debug;..\Middlewares_User\SystemView\Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Include;../Z02_Business/Init;../Z02_Business/Status_Task;../Z02_Business/LED_Task;../Z02_Business/System_Adaption;../Z01_BSP/LED
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F411CEU6.sct
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares_User\SEGGER_RTT
    ../Middlewares_User/SEGGER_RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/SystemView_FreeRTOS_V10
    ../Middlewares_User/SystemView/Src/: SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group Middlewares_User\EasyLogger
    ../Middlewares_User/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares_User/EasyLogger/port/: elog_port.c
    ../Middlewares_User/EasyLogger/debug/: debug.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../Z01_BSP/LED/: bsp_led_driver.c bsp_led_handler.c led.c
  group Business
    ../Z02_Business/Init/: os_init.c
    ../Z02_Business/Status_Task/: status_task.c
    ../Z02_Business/LED_Task/: led_task.c
    ../Z02_Business/System_Adaption/: system_adaption.c
software components: CMSIS:CORE 4.3.0
